options:
  parameters:
    author: Stefano Nicora
    generate_options: qt_gui
    id: Backscattering_Empfaenger
    output_language: python
    title: Backscattering - Receiver
  states: {}

blocks:
- name: RX_gain
  id: variable_qtgui_range
  parameters:
    comment: gain adjustment
    label: RX Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: bit_time_length
  id: variable
  parameters:
    comment: Time in ms for a single Bit
    value: '10'
  states: {}
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      desired channel where carrier
      is transmitted
    labels: '["1","2","3","4","5","6","7","8","9","10","11","12","13"]'
    num_opts: '0'
    options: '[2412e6, 2417e6, 2422e6, 2427e6, 2432e6, 2437e6, 2442e6, 2447e6, 2452e6, 2457e6, 2462e6, 2467e6, 2472e6]'
    orient: Qt.QHBoxLayout
    type: int
    value: '2422000000'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: |-
      Remove frequency shift
      in order to minimize the
      needed sample rate
    freq: '-12.5e6'
    sample_rate: samp_rate
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      Adjust length to match 
      bit length in accordance
      with samp_rate
    interp: int((samp_rate*bit_time_length) / 1000)
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble reference
    repeat: 'True'
    type: complex
    vector: (1,1,1,0,0,0,1,0,0,1,0)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Deinterleaving',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.array1 = []
              self.array2 = []
              self.array3 = []
              self.array4 = []
              self.array5 = []
              self.array6 = []
              self.array7 = []
              self.array8 = []
              self.counter = 0

          def work(self, input_items, output_items):
              self.array1[self.counter] = (self.array1[self.counter] | input_items[0].real)
              self.array2[self.counter] = (self.array2[self.counter] | input_items[0].real)
              self.array3[self.counter] = (self.array3[self.counter] | input_items[0].real)
              self.array4[self.counter] = (self.array4[self.counter] | input_items[0].real)
              self.array5[self.counter] = (self.array5[self.counter] | input_items[0].real)
              self.array6[self.counter] = (self.array6[self.counter] | input_items[0].real)
              self.array7[self.counter] = (self.array7[self.counter] | input_items[0].real)
              self.array8[self.counter] = (self.array8[self.counter] | input_items[0].real)
              self.counter = self.counter + 1
              if self.counter == 8:
                  output_items[0][:] = self.array1
                  output_items[0][:] = self.array2
                  output_items[0][:] = self.array3
                  output_items[0][:] = self.array4
                  output_items[0][:] = self.array5
                  output_items[0][:] = self.array6
                  output_items[0][:] = self.array7
                  output_items[0][:] = self.array8
                  self.array1 = []
                  self.array2 = []
                  self.array3 = []
                  self.array4 = []
                  self.array5 = []
                  self.array6 = []
                  self.array7 = []
                  self.array8 = []
                  self.counter = 0
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

      	def __init__(self):  # only default arguments here
      		gr.sync_block.__init__(
      			self,
      			name='Hamming',
      			in_sig=[np.complex64,np.complex64],
      			out_sig=[np.complex64]
      		)
      	def work(self, input_items, output_items):
      		if input_items[1].real > 10:
      			# revert hamming-encoding if preamble value is large enough
      			colum2or4 = 1
      			colum3or4 = 1
      			row2or4 = 1
      			row3or4 = 1
      			generalBitflip = 1
      			faultyBit = 0
      			# check if all parity bits are correct | 1 = flip occurred
      			if (input_items[0][1].real ^ input_items[0][2].real ^ input_items[0][3].real ^ input_items[0][4].real ^ input_items[0][5].real ^ input_items[0][6].real ^ input_items[0][7].real ^ input_items[0][8].real ^ input_items[0][9].real ^ input_items[0][10].real ^ input_items[0][11].real ^ input_items[0][12].real ^ input_items[0][13].real ^ input_items[0][14].real ^ input_items[0][15].real & 1) == 0:
      				generalBitflip = 0
      			if generalBitflip == 1:
      				print("There has been at least a second bit flip that couldn't be processed. Aborting...")
      				quit()
      			if (input_items[0][1].real ^ input_items[0][3].real ^ input_items[0][5].real ^ input_items[0][7].real ^ input_items[0][9].real ^ input_items[0][11].real ^ input_items[0][13].real ^ input_items[0][15].real & 1) == 0:
      				colum2or4 = 0
      			if (input_items[0][2].real ^ input_items[0][3].real ^ input_items[0][6].real ^ input_items[0][7].real ^ input_items[0][10].real ^ input_items[0][11].real ^ input_items[0][14].real ^ input_items[0][15].real & 1) == 0:
      				colum3or4 = 0
      			if (input_items[0][4].real ^ input_items[0][5].real ^ input_items[0][6].real ^ input_items[0][7].real ^ input_items[0][12].real ^ input_items[0][13].real ^ input_items[0][14].real ^ input_items[0][15].real & 1) == 0:
      				row2or4 = 0
      			if (input_items[0][8].real ^ input_items[0][9].real ^ input_items[0][10].real ^ input_items[0][11].real ^ input_items[0][12].real ^ input_items[0][13].real ^ input_items[0][14].real ^ input_items[0][15].real & 1) == 0:
      				row3or4 = 0
      			faultyBit = (row3or4 << 3) | (row2or4 << 2) | (colum3or4 << 1) | colum2or4 # calculate position of faulty / flipped bit
      			if faultyBit != 0:	# switch wrong bit
      				input_items[0][faultyBit] = input_items[0][faultyBit] ^ 1
      			output_items[0][:] = input_items[0]
      		return len(output_items[0])
    comment: |-
      IN 1: continuous data
      IN 2: enable threshold
  states: {}
- name: epy_block_0_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Print',
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              i = 0
          def work(self, input_items, output_items):
              print(input_items[0].real)
              time.sleep(0.1)
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import sys
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, corr_length=4096):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Correlation',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              
              # self.logg = gr.logger()
              self.corr_length = corr_length
              
              np.set_printoptions(threshold=sys.maxsize)
              self.buf = np.array([[], []])
              self.buf_out = np.array(np.zeros(self.corr_length))
              
          def work(self, input_items, output_items):
              self.buf = np.concatenate((self.buf, input_items), axis=1)
              
              tmp = np.array([])
              out_len = np.array(output_items).shape[1]
              
              #print("out len " + str(out_len))
              
              while self.buf.shape[1] >= self.corr_length:
                      tmp = self.buf[:, :self.corr_length]
                      self.buf = self.buf[:, self.corr_length:]
                      
                      corr = np.flip(np.correlate(tmp[0], tmp[1], 'full')[:self.corr_length])
                      self.buf_out = np.concatenate((self.buf_out, corr))
              
              output_items[0][:] = self.buf_out[:out_len]
              self.buf_out = self.buf_out[out_len:]
              
              # print("tmp " + str(tmp.shape))
              # print("out " + str(np.array(output_items).shape))
              
              return len(output_items[0])
    comment: Find preamble in signal
    corr_length: int((samp_rate*bit_time_length) / 1000)
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '2'
    ntaps: '16'
    samp_rate: samp_rate
    sym_rate: 1/bit_time_length * 1000
    type: fir_filter_ccf
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: chooser
    gain: RX_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_freqshift_cc_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_repeat_0, '0', epy_block_3, '1']
- [blocks_vector_source_x_0_0_0_0_0, '0', blocks_repeat_0, '0']
- [epy_block_0_0, '0', epy_block_0_1_1, '0']
- [epy_block_0_1_0, '0', epy_block_0_0, '0']
- [epy_block_3, '0', epy_block_0_1_0, '1']
- [root_raised_cosine_filter_0, '0', epy_block_0_1_0, '0']
- [root_raised_cosine_filter_0, '0', epy_block_3, '0']
- [soapy_limesdr_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
