options:
  parameters:
    author: Stefano Nicora
    generate_options: qt_gui
    id: Preamble_detection
    output_language: python
    title: Trägersignal-Generator
  states: {}

blocks:
- name: TX_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    labels: '["1","2","3","4","5","6","7","8","9","10","11","12","13"]'
    num_opts: '0'
    options: '[2412e6, 2417e6, 2422e6, 2427e6, 2432e6, 2437e6, 2442e6, 2447e6, 2452e6, 2457e6, 2462e6, 2467e6, 2472e6]'
    orient: Qt.QHBoxLayout
    type: int
    value: '2422000000'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '0'
    center_freq: chooser
    gain: TX_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: chooser
    gain: TX_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', soapy_bladerf_sink_0, '0']
- [analog_const_source_x_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
